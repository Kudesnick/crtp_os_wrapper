# Keil uVision project crtp.uvprojx, settings and files
target debug 411 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: crtp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: DEBUG
  c misc: -Wno-c++98-compat -Wno-c++98-compat-pedantic -Wno-global-constructors  -Wno-missing-variable-declarations -Wno-invalid-utf8 -Wno-gnu-zero-variadic-macro-arguments -Wno-c++20-designator
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\src\crtp.sct
  link misc: --predefine=-DSTM32F411xE
  group main
    ./src/: crtp.sct main.cpp
  group os
    ./src/os/: err.cpp misc.h os.h os.cpp thread.h
  group rtt
    ./src/rtt/: RTT_IO.cpp SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:Startup 2.6.3
